options:
  parameters:
    author: GOMEZ CERRO
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionPWM
    output_language: python
    title: Modulacion PWM
  states: {}

blocks:
- name: AA
  id: variable_qtgui_range
  parameters:
    label: A constante
    start: '-2'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '4'
    value: '4'
  states: {}
- name: Offset
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: 2*Amplitud
    freq: '10000'
    offset: '-Amplitud+Offset'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
